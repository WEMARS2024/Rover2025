Commit message: Simulation set up

File: src/rover_description/urdf/rover_base.xacro.urdf (robot description, URDF)
Before this commit: robot diff_drive, 5 links, 3 joints
Links:
- removed link camera
